FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fru-macaddr"
